# Keil uVision project ultrasonic.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ultrasonic
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group UART
    ./: uart.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
